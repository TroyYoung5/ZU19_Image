options:
  parameters:
    generate_options: qt_gui
    id: SDR_to_SDR_BPSK_CONTROL_AND_DISPLAY
    output_language: python
    title: SDR_to_SDR_BPSK
  states: {}

blocks:
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,4,1,1
    label: rx gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: tx gain
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '0'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /dev/null
    type: byte
    unbuffered: 'True'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,2,2,1
    name: '"Original Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 2,1,1,1
    name: '"Reconstructed Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,1,1
    name: '"After USRP Reads Data In"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,2,1
    name: '"After Constellation Modulator"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1,2,1
    marker1: '0'
    name: '"tx symbols"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,2,1,1
    marker1: '0'
    name: '"Reconstructed Bits"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_3_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,4,1,1
    marker1: '0'
    name: '"Reconstructed Bits Post CAC"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: localhost
    callback: set_rx_gain
    port: '8000'
    variable: rx_gain
  states: {}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: localhost
    callback: set_tx_gain
    port: '8000'
    variable: tx_gain
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:10000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:10001
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:10002
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_1
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:10003
    timeout: '100'
    type: byte
  states: {}
- name: zeromq_sub_source_0_0_2
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:10004
    timeout: '100'
    type: float
  states: {}
- name: zeromq_sub_source_0_0_2_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:10005
    timeout: '100'
    type: float
  states: {}

connections:
- [zeromq_sub_source_0, '0', qtgui_const_sink_x_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [zeromq_sub_source_0, '0', qtgui_time_sink_x_1_1, '0']
- [zeromq_sub_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_sub_source_0_0_0, '0', qtgui_const_sink_x_1, '0']
- [zeromq_sub_source_0_0_1, '0', blocks_file_sink_1, '0']
- [zeromq_sub_source_0_0_2, '0', qtgui_time_sink_x_3, '0']
- [zeromq_sub_source_0_0_2_0, '0', qtgui_time_sink_x_3_0, '0']

metadata:
  file_format: 1
  grc_version: 3.6.1git-10128-g92f5e418
